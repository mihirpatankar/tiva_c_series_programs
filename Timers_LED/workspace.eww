<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\Lesson1\counters.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\project.ewp</path>
    </project>
    <batchBuild />
</workspace>
